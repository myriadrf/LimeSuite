# Keil uVision project calibrationsLMS7_MCU.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: calibrationsLMS7_MCU +hex
  c flags: Optimize=9
  c include: .\common_src;.\mcu_src
  link misc: REMOVEUNUSED
  group Source Group 1
    ./common_src/: lms7002m_calibrations.c lms7002m_calibrations.h lms7002m_controls.c lms7002m_controls.h LMS7002M_parameters_compact.c LMS7002M_parameters_compact.h spi.h typedefs.h lms7002m_filters.c lms7002m_agc.c
    ./mcu_src/: LMS7002_REGx51.h main.c spi.c
