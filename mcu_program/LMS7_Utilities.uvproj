# Keil uVision project LMS7_Utilities.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: LMS7_Utilities +hex
  c flags: Optimize=9
  c include: .\common_src;.\mcu_src
  link misc: REMOVEUNUSED
  group Source Group 1
    ./common_src/: LMS7002M_parameters_compact.h spi.h typedefs.h
    ./mcu_src/: LMS7002_REGx51.h spi.c
    ./utilities_src/: main.c utilities.c
